# Keil uVision project 122.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: MDR32F9Q2I Milandr
  pack: Milandr.MDR32FxQI.1.2.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 122
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: bob.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.1.0i
