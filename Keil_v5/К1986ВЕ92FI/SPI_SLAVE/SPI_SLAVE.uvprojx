# Keil uVision project SPI_SLAVE.uvprojx, settings and files
target K1986BE92FI (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: K1986VE92xI Milandr
  pack: Milandr.MDR32FxQI.1.3.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SPI_SLAVE
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group app
    ./: main.c
software components: CMSIS Driver:SPI:Custom 1.0.0, CMSIS:CORE 5.5.0, Device:Startup 2.2.0i
