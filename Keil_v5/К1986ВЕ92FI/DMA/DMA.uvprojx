# Keil uVision project DMA.uvprojx, settings and files
target K1986BE92FI (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: K1986VE92xI Milandr
  pack: Milandr.MDR32FxQI.1.3.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DMA
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c include: ..\DMA;.\app;.\hw_init
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group app
    ./app/: main.c
  group hw_init
    ./hw_init/: hw_init.c hw_init.h
software components: Device:Startup 2.2.0i, Drivers:DMA 2.2.0i, Drivers:PORT 2.2.0i, Drivers:RST_CLK 2.2.0i, Drivers:UART 2.2.0i
